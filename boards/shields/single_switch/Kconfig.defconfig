## boards/shields/single_switch/Kconfig.defconfig
```kconfig
if SHIELD_SINGLE_SWITCH

config ZMK_KEYBOARD_NAME
    default "Single Switch"

endif
```
